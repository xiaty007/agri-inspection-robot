# IAR project demo.ewp, settings and files
configuration amber (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE; USE_STM32F4XX_NUCLEO; SENTRAL_TYPE_USING=6
  ICCARM.CCIncludePath2: ..\Inc; ..\src; ..\bsp; ..\bsp\oled; ..\user; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32F4xx-Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/bsp
    ../bsp/: hal_i2c.c util.c
    ../bsp/oled/: OLED_I2C.c
  group app/EWARM
    ./: startup_stm32f411xe.s
  group app/User
    ../Src/: main.c mm_loop.c mm_util.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
